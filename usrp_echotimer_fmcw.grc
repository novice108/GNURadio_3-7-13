<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_echotimer_fmcw</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5.9e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_fac</value></param>
<param><key>value</key><value>2**3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay_samp</value></param>
<param><key>value</key><value>24</value></param>
<param><key>label</key><value>Number delay samples</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res_cw</value></param>
<param><key>value</key><value>samp_rate/samp_cw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res_up</value></param>
<param><key>value</key><value>samp_rate/samp_up</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_output_buffer</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meas_duration</value></param>
<param><key>value</key><value>(samp_cw+samp_up+samp_down)/float(samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>int((samp_up+samp_down+samp_cw)*2)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>protect_samp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_res</value></param>
<param><key>value</key><value>3e8/2/sweep_freq</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_cw</value></param>
<param><key>value</key><value>2**14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_down</value></param>
<param><key>value</key><value>samp_up</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_up</value></param>
<param><key>value</key><value>2**14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sweep_freq</value></param>
<param><key>value</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>-150</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_res</value></param>
<param><key>value</key><value>samp_rate/samp_cw*3e8/2/center_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wait_to_start</value></param>
<param><key>value</key><value>0.02</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>1.0/decim_fac</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>samp_cw/decim_fac</value></param>
<param><key>name</key><value>CW</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>samp_up/decim_fac</value></param>
<param><key>name</key><value>UP</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>samp_up/decim_fac</value></param>
<param><key>name</key><value>DOWN</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>radar_estimator_fmcw</key>
<param><key>id</key><value>radar_estimator_fmcw_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>push_power</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>samp_down</key><value>samp_down/decim_fac</value></param>
<param><key>samp_up</key><value>samp_up/decim_fac</value></param>
<param><key>sweep_freq</key><value>sweep_freq</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_signal_generator_fmcw_c</key>
<param><key>id</key><value>radar_signal_generator_fmcw_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>freq_cw</key><value>-sweep_freq/2</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_cw</key><value>samp_cw</value></param>
<param><key>samp_down</key><value>samp_down</value></param>
<param><key>samp_up</key><value>samp_up</value></param>
<param><key>freq_sweep</key><value>sweep_freq</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>0</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>1</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>2</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>samp_cw/decim_fac</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_1</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>samp_up/decim_fac</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_2</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>samp_down/decim_fac</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>num_delay_samps</key><value>int(delay_samp)</value></param>
<param><key>antenna_rx</key><value>'J1'</value></param>
<param><key>args_rx</key><value>'addr=192.168.10.4'</value></param>
<param><key>gain_rx</key><value>rx_gain</value></param>
<param><key>wait_rx</key><value>wait_to_start</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>antenna_tx</key><value>'J1'</value></param>
<param><key>args_tx</key><value>'addr=192.168.10.6'</value></param>
<param><key>gain_tx</key><value>tx_gain</value></param>
<param><key>wait_tx</key><value>wait_to_start</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decim_fac</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>'serial=315AF6C'</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>"packet_len"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>'serial=315AF40'</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_fmcw_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in CW</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in UP</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in DOWN</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>radar_ts_fft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>radar_ts_fft_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0_0</source_block_id><sink_block_id>radar_ts_fft_cc_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0</source_block_id><sink_block_id>radar_find_max_peak_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_1</source_block_id><sink_block_id>radar_find_max_peak_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_2</source_block_id><sink_block_id>radar_find_max_peak_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
